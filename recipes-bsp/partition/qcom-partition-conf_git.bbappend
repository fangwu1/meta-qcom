FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0002-Add-maili-mtp-partition-configuration.patch"
